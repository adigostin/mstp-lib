# IAR project RstpTestApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2387 NXP LPC2387
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: drivers\; ..\mstp-lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: TestApp.srec
  ILINK.IlinkOutputFile: RstpTestApp.out
  ILINK.IlinkIcfFile: RstpTestApp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.cpp test.c
  group drivers
    drivers/: LPC23xx_enet.cpp LPC23xx_enet.h timer.cpp timer.h uart.cpp uart.h vic.cpp vic.h
  group mstp-lib
    ../mstp-lib/: stp.h
  group mstp-lib/internal
    ../mstp-lib/internal/: stp.cpp stp_base_types.cpp stp_base_types.h stp_bpdu.cpp stp_bpdu.h stp_bridge.h stp_log.cpp stp_log.h stp_md5.cpp stp_md5.h stp_port.h stp_procedures.cpp stp_procedures.h stp_sm.h stp_sm_bridge_detection.cpp stp_sm_l2gp_receive.cpp stp_sm_port_information.cpp stp_sm_port_protocol_migration.cpp stp_sm_port_receive.cpp stp_sm_port_role_selection.cpp stp_sm_port_role_transitions.cpp stp_sm_port_state_transition.cpp stp_sm_port_timers.cpp stp_sm_port_transmit.cpp stp_sm_topology_change.cpp
